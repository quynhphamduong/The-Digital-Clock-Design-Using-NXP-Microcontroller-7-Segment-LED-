# Keil uVision project EMB_MOCK.uvprojx, settings and files
target Target 1 (6220000::V6.22::ARMCLANG)
  device: S32K144HAxxxLLx NXP
  pack: Keil.S32_SDK_DFP.1.5.1
  cpu: IRAM(0x20000000,0x00007000) IRAM2(0x1FFF8000,0x00008000) IROM(0x00000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: EMB_MOCK
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x7000
  memory RVCT10: RAM 0x1fff8000 size 0x8000
  scatter file: ..\..\..\tool\p\Keil\S32_SDK_DFP\1.5.1\platform\devices\S32K144\linker\armc\S32K144_64_flash.sct
  group Source Code
    ./: INTERRUPT_SOURC.c LPIT_SOURC.c LPSPI_SOURC.c LPUART_SOURC.c PCC_SOURC.c PORT_SOURC.c SCG_SOURC.c SYSTEMTICK_SOURC.c Main.c EMB_MOCK_SOURC.c FTFC_SOURC.c UNIT_TEST_SOURC.c
  group Library
    ./: GPIO.h INTERRUPT.h LPIT.h LPSPI.h LPUART.h PCC.h PORT.h SCG.h SYSTEMTICK.h EMB_MOCK.h FTFC.h UNIT_TEST.h
software components: CMSIS:CORE 6.1.0, Device:Startup 2.0.0
